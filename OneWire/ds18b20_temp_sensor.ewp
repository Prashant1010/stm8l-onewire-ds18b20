# IAR project ds18b20_temp_sensor.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C4 STM8L152C4
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\prashant\Desktop\OneWire\lib\inc; C:\Users\prashant\Desktop\OneWire\stdlibraries\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group lib/inc
    lib/inc/: delay.h tempSensor.h
  group lib/src
    lib/src/: delay.c tempSensor.c
  group stdlibraries/inc
    stdlibraries/inc/: stm8l15x.h stm8l15x_clk.h stm8l15x_conf.h stm8l15x_gpio.h stm8l15x_tim2.h
  group stdlibraries/src
    stdlibraries/src/: stm8l15x_clk.c stm8l15x_gpio.c stm8l15x_tim2.c
